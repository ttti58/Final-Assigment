# IAR project SPI Final.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L152C6 STM8L152C6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: C:\Users\hera.fgatraining\Desktop\TranThanhDuy\Final Assigment\SPI\MyLib\inc; C:\Users\hera.fgatraining\Desktop\TranThanhDuy\MOCK_PROJECT_6\MyLib\src
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ./: main.c
  group MyLib/inc
    MyLib/inc/: Clock.h External.h Gpio.h Itc.h Lcd.h SPI.h stm8.h Usart.h
  group MyLib/src
    MyLib/src/: Lcd.c SPI.c stm8.c Usart.c
